# IAR project mbed-os-example-ble-HeartRate.ewp, settings and files
configuration mbed-os-example-ble-HeartRate (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DNRF52_PAN_36; -DNRF52_PAN_12; --enable_restrict; -DTOOLCHAIN_object; -DNRF52_PAN_15; -DNRF52_PAN_30; -DNRF52_PAN_31; --preinclude=mbed_config.h; -DCONFIG_GPIO_AS_PINRESET; -DBOARD_PCA10040; -DBOOTLOADER_SIZE=0x23000; -DNRF52_PAN_64; -DBOOTLOADER_ADDR=0x0; -DTARGET_NRF52; -DDEVICE_STCLK_OFF_DURING_SLEEP=1; -DDEVICE_LPTICKER=1; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DMBED_BUILD_TIMESTAMP=1530098799.84; -DDEVICE_I2C_ASYNCH=1; -DTARGET_FF_ARDUINO; -DTARGET_RTOS_M4_M7; -DCMSIS_VECTAB_VIRTUAL; -DDEVICE_PORTOUT=1; -DDEVICE_FLASH=1; -DTARGET_RELEASE; -DTARGET_LIKE_MBED; -DDEVICE_SERIAL_FC=1; -DAPPLICATION_ADDR=0x23000; -DTARGET_M4; -DDEVICE_ANALOGIN=1; -DTARGET_LIKE_CORTEX_M4; -D__CORTEX_M4; -DTARGET_CORTEX_M; -DNRF52_PAN_63; -DDEVICE_SERIAL=1; -DDEVICE_PORTIN=1; -DARM_MATH_CM4; -DDEVICE_ITM=1; -DAPPLICATION_SIZE=0x5d000; -DTARGET_MCU_NRF52832; -DNRF52_PAN_20; -DDEVICE_USTICKER=1; -DDEVICE_I2C=1; -DNRF52_PAN_53; -DDEVICE_INTERRUPTIN=1; -DNRF52; -DTARGET_NRF5x; -DMBED_TICKLESS; -DTARGET_UVISOR_UNSUPPORTED; -DTARGET_SOFTDEVICE_COMMON; --no_wrap_diagnostics; -DDEVICE_PWMOUT=1; -DDEVICE_SERIAL_ASYNCH=1; -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h"; -DDEVICE_TRNG=1; -DTARGET_NRF52_DK; -DTARGET_SOFTDEVICE_S132_FULL; -DTARGET_SDK_14_2; -DDEVICE_SPI=1; -D__MBED__=1; -DFEATURE_BLE=1; -DTOOLCHAIN_IAR; -DTARGET_NORDIC; -DNRF52_PAN_62; -DTARGET_CORTEX; -DNRF52_PAN_54; -DNRF52_PAN_55; -DSWI_DISABLE0; -DTARGET_NRF52832; -DNRF52_PAN_51; -D__FPU_PRESENT=1; -D__CMSIS_RTOS; -DDEVICE_SPI_ASYNCH=1; --guard_calls; -DNRF52_PAN_58; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; img; shields; source; mbed-os/.; mbed-os/features; mbed-os/features/cryptocell; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/frameworks/mbed-client-randlib; mbed-os/features/frameworks/mbed-client-randlib/mbed-client-randlib; mbed-os/features/frameworks/mbed-client-randlib/mbed-client-randlib/platform; mbed-os/features/frameworks/mbed-client-randlib/source; mbed-os/features/frameworks/mbed-coap; mbed-os/features/frameworks/mbed-coap/doxygen; mbed-os/features/frameworks/mbed-coap/mbed-coap; mbed-os/features/frameworks/mbed-coap/source; mbed-os/features/frameworks/mbed-coap/source/include; mbed-os/features/frameworks/mbed-trace; mbed-os/features/frameworks/mbed-trace/mbed-trace; mbed-os/features/frameworks/mbed-trace/source; mbed-os/features/frameworks/nanostack-libservice; mbed-os/features/frameworks/nanostack-libservice/mbed-client-libservice; mbed-os/features/frameworks/nanostack-libservice/mbed-client-libservice/platform; mbed-os/features/frameworks/nanostack-libservice/source; mbed-os/features/frameworks/nanostack-libservice/source/IPv6_fcf_lib; mbed-os/features/frameworks/nanostack-libservice/source/libBits; mbed-os/features/frameworks/nanostack-libservice/source/libList; mbed-os/features/frameworks/nanostack-libservice/source/libTrace; mbed-os/features/frameworks/nanostack-libservice/source/libTrace/scripts; mbed-os/features/frameworks/nanostack-libservice/source/libip6string; mbed-os/features/frameworks/nanostack-libservice/source/nsdynmemLIB; mbed-os/features/frameworks/nanostack-libservice/source/nvmHelper; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/mbedtls/targets; mbed-os/features/nanostack; mbed-os/features/nanostack/coap-service; mbed-os/features/nanostack/coap-service/coap-service; mbed-os/features/nanostack/coap-service/source; mbed-os/features/nanostack/coap-service/source/include; mbed-os/features/nanostack/mbed-mesh-api; mbed-os/features/nanostack/mbed-mesh-api/mbed-mesh-api; mbed-os/features/nanostack/mbed-mesh-api/source; mbed-os/features/nanostack/mbed-mesh-api/source/include; mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos; mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/cs_nvm; mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/nvm; mbed-os/features/nanostack/nanostack-interface; mbed-os/features/nanostack/sal-stack-nanostack-eventloop; mbed-os/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop; mbed-os/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/platform; mbed-os/features/nanostack/sal-stack-nanostack-eventloop/source; mbed-os/features/nanostack/sal-stack-nanostack; mbed-os/features/nanostack/sal-stack-nanostack/docs; mbed-os/features/nanostack/sal-stack-nanostack/docs/img; mbed-os/features/nanostack/sal-stack-nanostack/doxygen; mbed-os/features/nanostack/sal-stack-nanostack/nanostack; mbed-os/features/nanostack/sal-stack-nanostack/nanostack/platform; mbed-os/features/nanostack/sal-stack-nanostack/source; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/Generic; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Fragmentation; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/IPHC_Decode; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/MAC; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Mesh; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/ND; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/NVM; mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Thread; mbed-os/features/nanostack/sal-stack-nanostack/source/BorderRouter; mbed-os/features/nanostack/sal-stack-nanostack/source/Common_Protocols; mbed-os/features/nanostack/sal-stack-nanostack/source/Core; mbed-os/features/nanostack/sal-stack-nanostack/source/Core/include; mbed-os/features/nanostack/sal-stack-nanostack/source/DHCPv6_Server; mbed-os/features/nanostack/sal-stack-nanostack/source/MAC; mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/IEEE802_15_4; mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/ethernet; mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/serial; mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/virtual_rf; mbed-os/features/nanostack/sal-stack-nanostack/source/MLE; mbed-os/features/nanostack/sal-stack-nanostack/source/MPL; mbed-os/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE; mbed-os/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/Include; mbed-os/features/nanostack/sal-stack-nanostack/source/RPL; mbed-os/features/nanostack/sal-stack-nanostack/source/Security; mbed-os/features/nanostack/sal-stack-nanostack/source/Security/Common; mbed-os/features/nanostack/sal-stack-nanostack/source/Security/PANA; mbed-os/features/nanostack/sal-stack-nanostack/source/Security/TLS; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/mbedOS; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/Neighbor_cache; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/SHA256_Lib; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/Trickle; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/blacklist; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/etx; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/fhss; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/fnv_hash; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/load_balance; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/compiler; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/cpu; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/dns; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/mdns; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/poll; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/serial; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/stack; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mle_service; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/nd_proxy; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/pan_blacklist; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/utils; mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/whiteboard; mbed-os/features/nanostack/sal-stack-nanostack/source/configs; mbed-os/features/nanostack/sal-stack-nanostack/source/configs/base; mbed-os/features/nanostack/sal-stack-nanostack/source/ipv6_stack; mbed-os/features/nanostack/sal-stack-nanostack/source/libDHCPv6; mbed-os/features/nanostack/sal-stack-nanostack/source/libNET; mbed-os/features/nanostack/sal-stack-nanostack/source/libNET/src; mbed-os/features/nanostack/targets; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/features/netsocket/cellular; mbed-os/features/netsocket/cellular/generic_modem_driver; mbed-os/features/netsocket/emac-drivers; mbed-os/features/filesystem; mbed-os/features/filesystem/bd; mbed-os/features/filesystem/fat; mbed-os/features/filesystem/fat/ChaN; mbed-os/features/filesystem/littlefs; mbed-os/features/filesystem/littlefs/littlefs; mbed-os/features/cellular; mbed-os/features/cellular/easy_cellular; mbed-os/features/cellular/framework; mbed-os/features/cellular/framework/API; mbed-os/features/cellular/framework/AT; mbed-os/features/cellular/framework/common; mbed-os/features/cellular/framework/targets; mbed-os/features/cellular/framework/targets/QUECTEL; mbed-os/features/cellular/framework/targets/QUECTEL/BC95; mbed-os/features/cellular/framework/targets/QUECTEL/BG96; mbed-os/features/cellular/framework/targets/QUECTEL/UG96; mbed-os/features/cellular/framework/targets/TELIT; mbed-os/features/cellular/framework/targets/TELIT/HE910; mbed-os/features/cellular/framework/targets/UBLOX; mbed-os/features/cellular/framework/targets/UBLOX/PPP; mbed-os/features/lorawan; mbed-os/features/lorawan/lorastack; mbed-os/features/lorawan/lorastack/mac; mbed-os/features/lorawan/lorastack/phy; mbed-os/features/lorawan/system; mbed-os/features/nvstore; mbed-os/features/nvstore/source; mbed-os/features/device_key; mbed-os/features/device_key/source; mbed-os/cmsis; mbed-os/cmsis/TARGET_CORTEX_M; mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/TARGET_CORTEX; mbed-os/rtos/TARGET_CORTEX/rtx4; mbed-os/rtos/TARGET_CORTEX/rtx5; mbed-os/rtos/TARGET_CORTEX/rtx5/Include; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR/TARGET_RTOS_M4_M7; mbed-os/rtos/TARGET_CORTEX/rtx5/Source; mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M; mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_IAR; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_NORDIC; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/TARGET_NRF52_DK; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/device; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/device/TOOLCHAIN_IAR; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/ble; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/ble/ble_radio_notification; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/libraries; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/libraries/bootloader; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/libraries/bootloader/dfu; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/libraries/fstorage; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/softdevice; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/softdevice/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL/doc; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL/headers; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL/headers/nrf52; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL/hex; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/boards; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/device; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/ble_flash; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/clock; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/comp; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/delay; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/gpiote; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/hal; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/i2s; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/lpcomp; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/pdm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/power; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/ppi; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/pwm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/qdec; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/qspi; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/radio_config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/rng; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/rtc; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/saadc; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/sdio; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/sdio/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/spi_master; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/spi_slave; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/swi; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/systick; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/timer; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/twi_master; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/twis_slave; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/uart; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/usbd; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/wdt; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/atomic; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/atomic_fifo; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/balloc; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_log; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_log/src; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_memobj; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_section_vars; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/fds; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/fstorage; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/queue; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/strerror; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/util; mbed-os/features/FEATURE_BLE; mbed-os/features/FEATURE_BLE/ble; mbed-os/features/FEATURE_BLE/ble/services; mbed-os/features/FEATURE_BLE/ble/generic; mbed-os/features/FEATURE_BLE/ble/pal; mbed-os/features/FEATURE_BLE/source; mbed-os/features/FEATURE_BLE/source/services; mbed-os/features/FEATURE_BLE/source/generic; mbed-os/features/FEATURE_BLE/targets; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/btle; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/btle/custom; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/common; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -DCMSIS_VECTAB_VIRTUAL; -DNRF52; -D__FPU_PRESENT=1; -D__MBED_CMSIS_RTOS_CM; -D__CMSIS_RTOS; -DBOARD_PCA10040; -DNRF52_PAN_12; -DNRF52_PAN_15; -DNRF52_PAN_58; -DNRF52_PAN_55; -DNRF52_PAN_54; -DNRF52_PAN_31; -DNRF52_PAN_30; -DNRF52_PAN_51; -DNRF52_PAN_36; -DNRF52_PAN_53; -DMBED_TICKLESS; -DTARGET_NRF52832; -D__CORTEX_M4; -DCONFIG_GPIO_AS_PINRESET; -DSWI_DISABLE0; -DNRF52_PAN_20; -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h"; -DNRF52_PAN_64; -DNRF52_PAN_62; -DNRF52_PAN_63; -DARM_MATH_CM4
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/device/TOOLCHAIN_IAR/nRF52832.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib; --config_def MBED_APP_START=0x23000; --config_def MBED_APP_SIZE=0x5d000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group mbed-os-example-ble-HeartRate
    ./: temp_hum.h
    /tmp/tmp9eTBvo/: mbed_config.h
  group source
    source/: main.cpp
  group mbed-os
    mbed-os/: mbed.h
    mbed-os/features/frameworks/greentea-client/greentea-client/: test_env.h greentea_serial.h greentea_metrics.h
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    mbed-os/features/frameworks/mbed-client-randlib/mbed-client-randlib/: randLIB.h
    mbed-os/features/frameworks/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
    mbed-os/features/frameworks/mbed-coap/mbed-coap/: sn_coap_header.h sn_coap_protocol.h sn_config.h
    mbed-os/features/frameworks/mbed-coap/source/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    mbed-os/features/frameworks/mbed-trace/mbed-trace/: mbed_trace.h
    mbed-os/features/frameworks/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
    mbed-os/features/frameworks/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ecp_internal.h aria.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h ssl.h net_sockets.h platform_util.h platform_time.h rsa_internal.h cmac.h ssl_cache.h config-no-entropy.h
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/features/nanostack/coap-service/coap-service/: coap_service_api.h
    mbed-os/features/nanostack/coap-service/source/include/: coap_connection_handler.h coap_message_handler.h coap_security_handler.h coap_service_api_internal.h
    mbed-os/features/nanostack/mbed-mesh-api/mbed-mesh-api/: LoWPANNDInterface.h MeshInterfaceNanostack.h NanostackEMACInterface.h NanostackEthernetInterface.h NanostackRfInterface.h ThreadInterface.h mesh_interface_types.h
    mbed-os/features/nanostack/mbed-mesh-api/source/include/: NanostackMemoryManager.h callback_handler.h enet_tasklet.h mesh_system.h nd_tasklet.h thread_tasklet.h
    mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/: arm_hal_interrupt_private.h ns_event_loop.h ns_hal_init.h arm_hal_interrupt.c arm_hal_random.c ns_event_loop.c ns_hal_init.c arm_hal_timer.cpp
    mbed-os/features/nanostack/nanostack-interface/: Nanostack.h NanostackEthernetPhy.h NanostackInterface.h NanostackLockGuard.h NanostackPhy.h NanostackRfPhy.h Nanostack.cpp
    mbed-os/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
    mbed-os/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
    mbed-os/features/nanostack/sal-stack-nanostack-eventloop/source/: event.h ns_timer.h timer_sys.h event.c ns_timeout.c ns_timer.c system_timer.c minar_hal_timer.cpp
    mbed-os/features/nanostack/sal-stack-nanostack/nanostack/: cca_api.h ccmLIB.h dhcp_service_api.h ethernet_mac_api.h fhss_api.h fhss_config.h mac_api.h mac_common_defines.h mac_filter_api.h mac_mcps.h mlme.h multicast_api.h net_6lowpan_parameter_api.h net_address_extension.h net_fhss.h net_interface.h net_ipv6_api.h net_load_balance_api.h net_mle_api.h net_nvm_api.h net_nwk_scan.h net_pana_parameters_api.h net_polling_api.h net_rpl.h net_sleep.h net_test_api.h net_thread_test.h ns_address.h ns_file_system.h ns_mdns_api.h ns_sha256.h ns_virtual_rf_api.h nwk_stats_api.h serial_mac_api.h shalib.h socket_api.h sw_mac.h thread_bbr_api.h thread_border_router_api.h thread_commissioning_api.h thread_dhcpv6_server.h thread_diagcop_lib.h thread_lowpower_api.h thread_management_api.h thread_management_if.h thread_meshcop_lib.h thread_net_config_api.h whiteboard_api.h
    mbed-os/features/nanostack/sal-stack-nanostack/nanostack/platform/: arm_hal_aes.h arm_hal_phy.h os_whiteboard.h topo_trace.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/: nsconfig.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/: lowpan_adaptation_interface.h adaptation_interface.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/: network_lib.h protocol_6lowpan.h protocol_6lowpan_bootstrap.h protocol_6lowpan_interface.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Fragmentation/: cipv6_fragmenter.h cipv6_fragmenter.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/IPHC_Decode/: cipv6.h iphc_compress.h iphc_decompress.h lowpan_context.h 6lowpan_iphc.c iphc_compress.c iphc_decompress.c lowpan_context.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/MAC/: beacon_handler.h mac_data_poll.h mac_helper.h mac_pairwise_key.h mac_response_handler.h beacon_handler.c mac_data_poll.c mac_helper.c mac_pairwise_key.c mac_response_handler.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Mesh/: mesh.h mesh.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/ND/: nd_defines.h nd_router_object.h nd_router_object.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/NVM/: nwk_nvm.h nwk_nvm.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Thread/: thread_address_registration_client.h thread_bbr_api_internal.h thread_beacon.h thread_bootstrap.h thread_border_router_api_internal.h thread_commissioning_if.h thread_common.h thread_config.h thread_constants.h thread_dhcpv6_client.h thread_diagnostic.h thread_discovery.h thread_extension.h thread_extension_bbr.h thread_extension_bootstrap.h thread_host_bootstrap.h thread_joiner_application.h thread_leader_service.h thread_lowpower_private_api.h thread_management_client.h thread_management_internal.h thread_management_server.h thread_mdns.h thread_mle_message_handler.h thread_nd.h thread_network_data_lib.h thread_network_data_storage.h thread_network_synch.h thread_nvm_store.h thread_resolution_client.h thread_resolution_server.h thread_router_bootstrap.h thread_routing.h thread_tmfcop_lib.h thread_bbr_api.c thread_beacon.c thread_bootstrap.c thread_border_router_api.c thread_commissioning_api.c thread_commissioning_if.c thread_common.c thread_dhcpv6_client.c thread_diagnostic.c thread_discovery.c thread_host_bootstrap.c thread_joiner_application.c thread_leader_service.c thread_lowpower_private_api.c thread_management_api.c thread_management_client.c thread_management_if.c thread_management_server.c thread_mdns.c thread_meshcop_lib.c thread_mle_message_handler.c thread_nd.c thread_net_config_api.c thread_network_data_lib.c thread_network_data_storage.c thread_network_synch.c thread_nvm_store.c thread_resolution_client.c thread_resolution_server.c thread_router_bootstrap.c thread_routing.c thread_test_api.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/BorderRouter/: border_router.h border_router.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Common_Protocols/: icmpv6.h icmpv6_prefix.h icmpv6_radv.h ip.h ipv6.h ipv6_constants.h ipv6_flow.h ipv6_fragmentation.h ipv6_resolution.h mld.h tcp.h udp.h icmpv6.c icmpv6_prefix.c icmpv6_radv.c ipv6.c ipv6_flow.c ipv6_fragmentation.c ipv6_resolution.c mld.c tcp.c udp.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Core/include/: address.h ns_buffer.h ns_error_types.h sockbuf.h socket.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/DHCPv6_Server/: DHCPv6_server_service.h DHCPv6_Server_service.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/: rf_driver_storage.h rf_driver_storage.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/IEEE802_15_4/: mac_defines.h mac_fhss_callbacks.h mac_filter.h mac_header_helper_functions.h mac_indirect_data.h mac_mcps_sap.h mac_mlme.h mac_pd_sap.h mac_security_mib.h mac_timer.h sw_mac_internal.h mac_fhss_callbacks.c mac_filter.c mac_header_helper_functions.c mac_indirect_data.c mac_mcps_sap.c mac_mlme.c mac_pd_sap.c mac_security_mib.c mac_timer.c sw_mac.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/virtual_rf/: virtual_rf_defines.h virtual_rf_client.c virtual_rf_driver.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MLE/: mle.h mle_tlv.h mle.c mle_tlv.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MPL/: mpl.h mpl.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/Include/: protocol.h protocol_abstract.h protocol_stats.h protocol_timer.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/RPL/: rpl_control.h rpl_data.h rpl_downward.h rpl_mrhof.h rpl_objective.h rpl_of0.h rpl_policy.h rpl_protocol.h rpl_structures.h rpl_upward.h rpl_control.c rpl_data.c rpl_downward.c rpl_mrhof.c rpl_objective.c rpl_of0.c rpl_policy.c rpl_upward.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Security/Common/: sec_lib.h sec_lib_definitions.h security_lib.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Security/PANA/: eap_protocol.h pana.h pana_avp.h pana_eap_header.h pana_header.h pana_internal_api.h pana_nvm.h pana_relay_table.h eap_protocol.c pana.c pana_avp.c pana_client.c pana_eap_header.c pana_header.c pana_relay_table.c pana_server.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Security/TLS/: tls_ccm_crypt.h tls_lib.h tls_ccm_crypt.c tls_lib.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/Neighbor_cache/: neighbor_table_definition.h neighbor_cache.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/Trickle/: trickle.h trickle.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/blacklist/: blacklist.h blacklist.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/etx/: etx.h etx.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/fhss/: channel_list.h fhss.h fhss_beacon.h fhss_channel.h fhss_mac_interface.h fhss_statistics.h channel_list.c fhss.c fhss_beacon.c fhss_beacon_tasklet.c fhss_channel.c fhss_configuration_interface.c fhss_mac_interface.c fhss_statistics.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/fnv_hash/: fnv_hash.h fnv_hash.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/load_balance/: load_balance_api.h load_balance.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/: fnet_user_config.h ns_fnet_events.h ns_fnet_types.h ns_fnet_events.c ns_fnet_port.c ns_mdns_api.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/: fnet.h fnet_config.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/compiler/: fnet_comp.h fnet_comp_config.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/cpu/: fnet_cpu.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/: fnet_services.h fnet_services_config.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/dns/: fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/mdns/: fnet_mdns.h fnet_mdns_config.h fnet_mdns.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/poll/: fnet_poll.h fnet_poll.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/serial/: fnet_serial.h fnet_serial_config.h
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/stack/: fnet_arp.h fnet_assert.h fnet_debug.h fnet_error.h fnet_eth.h fnet_icmp6.h fnet_inet.h fnet_ip.h fnet_ip6.h fnet_isr.h fnet_mempool.h fnet_nd6.h fnet_netbuf.h fnet_netif.h fnet_netif_prv.h fnet_socket.h fnet_stack.h fnet_stack_config.h fnet_stdlib.h fnet_timer.h fnet_timer_prv.h fnet_stdlib.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mle_service/: mle_service_api.h mle_service_buffer.h mle_service_interface.h mle_service_security.h mle_service.c mle_service_buffer.c mle_service_interface.c mle_service_security.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/nd_proxy/: nd_proxy.h nd_proxy.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/pan_blacklist/: pan_blacklist_api.h pan_blacklist.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/utils/: isqrt.h ns_crc.h isqrt.c ns_crc.c ns_file_system.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/whiteboard/: whiteboard.h whiteboard.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/ipv6_stack/: ipv6_routing_table.h protocol_ipv6.h ipv6_routing_table.c protocol_ipv6.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/libDHCPv6/: libDHCPv6.h libDHCPv6_server.h dhcp_service_api.c libDHCPv6.c libDHCPv6_server.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/libNET/src/: net_load_balance_internal.h multicast_api.c net_6lowpan_parameter_api.c net_ipv6.c net_load_balance.c net_mle.c net_rpl.c net_short_address_extension.c net_test.c ns_net.c socket_api.c
    mbed-os/features/netsocket/: CellularBase.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.h Socket.h SocketAddress.h TCPServer.h TCPSocket.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h DNS.h nsapi.h nsapi_dns.h nsapi_types.h EMAC.h nsapi_ppp.h EMACInterface.h EMACMemoryManager.h EthernetInterface.h OnboardNetworkStack.h NetworkInterface.cpp NetworkStack.cpp Socket.cpp SocketAddress.cpp TCPServer.cpp TCPSocket.cpp UDPSocket.cpp WiFiAccessPoint.cpp nsapi_dns.cpp EMACInterface.cpp EMACMemoryManager.cpp EthernetInterface.cpp NetworkInterfaceDefaults.cpp
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.h PPPCellularInterface.h UARTCellularInterface.h OnboardCellularInterface.cpp PPPCellularInterface.cpp UARTCellularInterface.cpp
    mbed-os/features/filesystem/: Dir.h File.h FileSystem.h mbed_filesystem.h Dir.cpp File.cpp FileSystem.cpp
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.h HeapBlockDevice.h SlicingBlockDevice.h MBRBlockDevice.h ProfilingBlockDevice.h ExhaustibleBlockDevice.h ObservingBlockDevice.h ReadOnlyBlockDevice.h BufferedBlockDevice.h FlashSimBlockDevice.h ChainingBlockDevice.cpp HeapBlockDevice.cpp SlicingBlockDevice.cpp MBRBlockDevice.cpp ProfilingBlockDevice.cpp ExhaustibleBlockDevice.cpp ObservingBlockDevice.cpp ReadOnlyBlockDevice.cpp BufferedBlockDevice.cpp FlashSimBlockDevice.cpp
    mbed-os/features/filesystem/fat/: FATFileSystem.h FATFileSystem.cpp
    mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.h ffconf.h integer.h ff.cpp ffunicode.cpp
    mbed-os/features/filesystem/littlefs/: LittleFileSystem.h LittleFileSystem.cpp
    mbed-os/features/filesystem/littlefs/littlefs/: lfs.h lfs_util.h lfs.c lfs_util.c
    mbed-os/features/cellular/easy_cellular/: CellularConnectionFSM.h EasyCellularConnection.h APN_db.h CellularConnectionFSM.cpp EasyCellularConnection.cpp
    mbed-os/features/cellular/framework/API/: CellularDevice.h CellularInformation.h CellularNetwork.h CellularPower.h CellularSIM.h CellularSMS.h
    mbed-os/features/cellular/framework/AT/: ATHandler.h AT_CellularBase.h AT_CellularDevice.h AT_CellularInformation.h AT_CellularNetwork.h AT_CellularPower.h AT_CellularSIM.h AT_CellularSMS.h AT_CellularStack.h ATHandler.cpp AT_CellularBase.cpp AT_CellularDevice.cpp AT_CellularInformation.cpp AT_CellularNetwork.cpp AT_CellularPower.cpp AT_CellularSIM.cpp AT_CellularSMS.cpp AT_CellularStack.cpp
    mbed-os/features/cellular/framework/common/: CellularList.h CellularLog.h CellularTargets.h CellularUtil.h CellularCommon.h CellularUtil.cpp CellularLog.cpp
    mbed-os/features/cellular/framework/targets/QUECTEL/BC95/: QUECTEL_BC95.h QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularPower.h QUECTEL_BC95_CellularStack.h QUECTEL_BC95_CellularSIM.h QUECTEL_BC95.cpp QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularPower.cpp QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularSIM.cpp
    mbed-os/features/cellular/framework/targets/QUECTEL/BG96/: QUECTEL_BG96.h QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularStack.h QUECTEL_BG96_CellularPower.h QUECTEL_BG96.cpp QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularStack.cpp QUECTEL_BG96_CellularPower.cpp
    mbed-os/features/cellular/framework/targets/QUECTEL/UG96/: QUECTEL_UG96.h QUECTEL_UG96_CellularNetwork.h QUECTEL_UG96_CellularPower.h QUECTEL_UG96.cpp QUECTEL_UG96_CellularNetwork.cpp QUECTEL_UG96_CellularPower.cpp
    mbed-os/features/cellular/framework/targets/TELIT/HE910/: TELIT_HE910.h TELIT_HE910_CellularNetwork.h TELIT_HE910_CellularPower.h TELIT_HE910.cpp TELIT_HE910_CellularNetwork.cpp TELIT_HE910_CellularPower.cpp
    mbed-os/features/cellular/framework/targets/UBLOX/PPP/: UBLOX_PPP.h UBLOX_PPP_CellularNetwork.h UBLOX_PPP_CellularPower.h UBLOX_PPP.cpp UBLOX_PPP_CellularNetwork.cpp UBLOX_PPP_CellularPower.cpp
    mbed-os/features/lorawan/: LoRaRadio.h LoRaWANBase.h LoRaWANInterface.h LoRaWANStack.h lorawan_types.h LoRaWANInterface.cpp LoRaWANStack.cpp
    mbed-os/features/lorawan/lorastack/mac/: LoRaMac.h LoRaMacChannelPlan.h LoRaMacCommand.h LoRaMacCrypto.h LoRaMac.cpp LoRaMacChannelPlan.cpp LoRaMacCommand.cpp LoRaMacCrypto.cpp
    mbed-os/features/lorawan/lorastack/phy/: LoRaPHY.h LoRaPHYAS923.h LoRaPHYAU915.h LoRaPHYCN470.h LoRaPHYCN779.h LoRaPHYEU433.h LoRaPHYEU868.h LoRaPHYIN865.h LoRaPHYKR920.h LoRaPHYUS915.h LoRaPHYUS915Hybrid.h lora_phy_ds.h loraphy_target.h LoRaPHY.cpp LoRaPHYAS923.cpp LoRaPHYAU915.cpp LoRaPHYCN470.cpp LoRaPHYCN779.cpp LoRaPHYEU433.cpp LoRaPHYEU868.cpp LoRaPHYIN865.cpp LoRaPHYKR920.cpp LoRaPHYUS915.cpp LoRaPHYUS915Hybrid.cpp
    mbed-os/features/lorawan/system/: LoRaWANTimer.h lorawan_data_structures.h LoRaWANTimer.cpp
    mbed-os/features/nvstore/source/: nvstore.h nvstore.cpp
    mbed-os/features/device_key/source/: DeviceKey.h DeviceKey.cpp
    mbed-os/cmsis/: RTE_Components.h mbed_cmsis_conf.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_compiler.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h mbed_tz_context.c
    mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h MbedCRC.h SerialWireOutput.h TableCRC.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp RawSerial.cpp SPI.cpp Ticker.cpp Timer.cpp TimerEvent.cpp SPISlave.cpp UARTSerial.cpp Serial.cpp SerialBase.cpp MbedCRC.cpp TableCRC.cpp Timeout.cpp
    mbed-os/events/: Event.h EventQueue.h mbed_events.h mbed_shared_queues.h EventQueue.cpp mbed_shared_queues.cpp
    mbed-os/events/equeue/: equeue.h equeue_platform.h equeue.c equeue_posix.c equeue_mbed.cpp
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h EventFlags.h rtos_idle.h ConditionVariable.h Kernel.h Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp EventFlags.cpp ConditionVariable.cpp Kernel.cpp
    mbed-os/rtos/TARGET_CORTEX/: mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h SysTimer.h mbed_boot.c mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.h RTX_Config.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rt_OsEventObserver.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.h mbed_rtx_fault_handler.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h crc_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h flash_api.h critical_section_api.h itm_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_flash_api.c mbed_sleep_manager.c mbed_critical_section_api.c mbed_itm_api.c mbed_lp_ticker_wrapper.cpp
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h mbed_preprocessor.h mbed_application.h mbed_critical.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_toolchain.h mbed_wait_api.h sleep.h ATCmdParser.h DirHandle.h FileBase.h NonCopyable.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h CriticalSectionLock.h DeepSleepLock.h mbed_poll.h FileHandle.h mbed_power_mgmt.h FileLike.h ScopedLock.h Stream.h mbed_mktime.h mbed_error_hist.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_application.c mbed_stats.c mbed_error_hist.c mbed_sdk_boot.c mbed_mktime.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_mem_trace.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp mbed_retarget.cpp ATCmdParser.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp Stream.cpp mbed_poll.cpp
    mbed-os/targets/TARGET_NORDIC/: mbed_rtx.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/: gpio_object.h nrf5x_lf_clk_helper.h common_rtc.c gpio_api.c pinmap.c port_api.c rtc_api.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/: PeripheralPins.h common_rtc.h object_owners.h objects.h pinmap_ex.h us_ticker.h PeripheralPinsDefault.c analogin_api.c critical_section_api.c flash_api.c i2c_api.c itm_api.c lp_ticker.c object_owners.c pinmap_ex.c pwmout_api.c reloc_vector_table.c serial_api.c sleep.c spi_api.c trng_api.c us_ticker.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/: PeripheralNames.h PortNames.h PeripheralPins.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/TARGET_NRF52_DK/: PinNames.h device.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/config/: sdk_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/device/: cmsis.h cmsis_nvic.h system_nrf52.h cmsis_nvic.c system_nrf52.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/ble/ble_radio_notification/: ble_radio_notification.h ble_radio_notification.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/libraries/bootloader/dfu/: nrf_dfu_mbr.h nrf_dfu_types.h nrf_dfu_mbr.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/libraries/fstorage/: nrf_fstorage_sd.h nrf_fstorage_sd.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_COMMON/softdevice/common/: nrf_sdh.h nrf_sdh_ant.h nrf_sdh_ble.h nrf_sdh_soc.h nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_soc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL/headers/: ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_ble.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/TARGET_SOFTDEVICE_S132_FULL/headers/nrf52/: nrf_mbr.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/boards/: arduino_primo.h boards.h nrf6310.h pca10000.h pca10001.h pca10003.h pca10028.h pca10031.h pca10036.h pca10040.h pca10056.h pca20006.h wt51822.h boards.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/device/: compiler_abstraction.h nrf.h nrf51.h nrf51422_peripherals.h nrf51802_peripherals.h nrf51822_peripherals.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf51_to_nrf52810.h nrf51_to_nrf52840.h nrf52.h nrf52810.h nrf52810_bitfields.h nrf52810_peripherals.h nrf52832_peripherals.h nrf52840.h nrf52840_bitfields.h nrf52840_peripherals.h nrf52_bitfields.h nrf52_name_change.h nrf52_to_nrf52810.h nrf52_to_nrf52840.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/ble_flash/: ble_flash.h ble_flash.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/clock/: nrf_drv_clock.h nrf_drv_clock.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/common/: nrf_drv_common.h nrf_drv_common.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/comp/: nrf_drv_comp.h nrf_drv_comp.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/delay/: nrf_delay.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/gpiote/: nrf_drv_gpiote.h nrf_drv_gpiote.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/hal/: nrf_clock.h nrf_comp.h nrf_ecb.h nrf_egu.h nrf_gpio.h nrf_gpiote.h nrf_i2s.h nrf_lpcomp.h nrf_nvmc.h nrf_pdm.h nrf_peripherals.h nrf_power.h nrf_ppi.h nrf_pwm.h nrf_qdec.h nrf_qspi.h nrf_rng.h nrf_rtc.h nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_systick.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_twim.h nrf_twis.h nrf_uart.h nrf_uarte.h nrf_usbd.h nrf_wdt.h nrf_ecb.c nrf_nvmc.c nrf_saadc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/i2s/: nrf_drv_i2s.h nrf_drv_i2s.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/lpcomp/: nrf_drv_lpcomp.h nrf_drv_lpcomp.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/pdm/: nrf_drv_pdm.h nrf_drv_pdm.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/power/: nrf_drv_power.h nrf_drv_power.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/ppi/: nrf_drv_ppi.h nrf_drv_ppi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/pwm/: nrf_drv_pwm.h nrf_drv_pwm.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/qdec/: nrf_drv_qdec.h nrf_drv_qdec.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/qspi/: nrf_drv_qspi.h nrf_drv_qspi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/radio_config/: radio_config.h radio_config.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/rng/: nrf_drv_rng.h nrf_drv_rng.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/rtc/: nrf_drv_rtc.h nrf_drv_rtc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/saadc/: nrf_drv_saadc.h nrf_drv_saadc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/sdio/: sdio.h sdio.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/sdio/config/: sdio_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/spi_master/: nrf_drv_spi.h nrf_drv_spi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/spi_slave/: nrf_drv_spis.h nrf_drv_spis.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/swi/: nrf_drv_swi.h nrf_drv_swi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/systick/: nrf_drv_systick.h nrf_drv_systick.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/timer/: nrf_drv_timer.h nrf_drv_timer.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/twi_master/: nrf_drv_twi.h nrf_drv_twi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/twis_slave/: nrf_drv_twis.h nrf_drv_twis.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/uart/: nrf_drv_uart.h nrf_drv_uart.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/usbd/: nrf_drv_usbd.h nrf_drv_usbd_errata.h nrf_drv_usbd.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/drivers_nrf/wdt/: nrf_drv_wdt.h nrf_drv_wdt.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/atomic/: nrf_atomic.h nrf_atomic_internal.h nrf_atomic_sanity_check.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/atomic_fifo/: nrf_atfifo.h nrf_atfifo_internal.h nrf_atfifo.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/balloc/: nrf_balloc.h nrf_balloc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_log/: nrf_log.h nrf_log_backend_interface.h nrf_log_backend_rtt.h nrf_log_backend_uart.h nrf_log_ctrl.h nrf_log_default_backends.h nrf_log_str_formatter.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_log/src/: nrf_log_backend_serial.h nrf_log_ctrl_internal.h nrf_log_internal.h nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_memobj/: nrf_memobj.h nrf_memobj.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/experimental_section_vars/: nrf_section.h nrf_section_iter.h nrf_section_iter.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/fds/: fds.h fds_internal_defs.h fds.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/fstorage/: nrf_fstorage.h nrf_fstorage.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/queue/: nrf_queue.h nrf_queue.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/strerror/: nrf_strerror.h nrf_strerror.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_SDK_14_2/libraries/util/: app_error.h app_error_weak.h app_util.h app_util_bds.h app_util_platform.h nordic_common.h nrf_assert.h nrf_bitmask.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.h sdk_os.h sdk_resources.h app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    mbed-os/features/FEATURE_BLE/ble/: BLE.h BLEInstanceBase.h BLEProtocol.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h blecommon.h deprecate.h ArrayView.h BLETypes.h SafeEnum.h
    mbed-os/features/FEATURE_BLE/ble/services/: BatteryService.h DFUService.h DeviceInformationService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h LinkLossService.h UARTService.h URIBeaconConfigService.h iBeacon.h
    mbed-os/features/FEATURE_BLE/ble/generic/: GenericGattClient.h GenericGap.h GenericSecurityManager.h FileSecurityDb.h MemorySecurityDb.h SecurityDb.h
    mbed-os/features/FEATURE_BLE/ble/pal/: AttClient.h AttClientToGattClientAdapter.h AttServerMessage.h EventQueue.h GapEvents.h GapTypes.h GenericAccessService.h PalGap.h PalGattClient.h SimpleAttServerMessage.h SimpleEventQueue.h ConnectionEventMonitor.h PalSecurityManager.h SigningEventMonitor.h
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/: nRF5xCrypto.h nRF5xGap.h nRF5xGattServer.h nRF5xPalGattClient.h nRF5xPalSecurityManager.h nRF5xn.h projectconfig.h nRF5xCrypto.cpp nRF5xGap.cpp nRF5xGattServer.cpp nRF5xPalGattClient.cpp nRF5xPalSecurityManager.cpp nRF5xn.cpp
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/btle/: btle.h btle_clock.h btle.cpp
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/btle/custom/: custom_helper.h custom_helper.cpp
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF52/source/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR/: cmain.S
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR/TARGET_RTOS_M4_M7/: irq_cm4f.S
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_IAR/: except.S
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5x/TARGET_NRF52/TARGET_MCU_NRF52832/device/TOOLCHAIN_IAR/: startup_NRF52832_IAR.S
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/mbed-client-randlib/source/: randLIB.c
    mbed-os/features/frameworks/mbed-coap/source/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    mbed-os/features/frameworks/mbed-trace/source/: mbed_trace.c
    mbed-os/features/frameworks/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
    mbed-os/features/frameworks/nanostack-libservice/source/libBits/: common_functions.c
    mbed-os/features/frameworks/nanostack-libservice/source/libList/: ns_list.c
    mbed-os/features/frameworks/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
    mbed-os/features/frameworks/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
    mbed-os/features/frameworks/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c cmac.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c rsa_internal.c ssl_ciphersuites.c ssl_cli.c ssl_tls.c ssl_srv.c ssl_ticket.c x509.c threading.c timing.c version.c version_features.c x509_crl.c x509_create.c x509_crt.c x509_csr.c ssl_cache.c x509write_crt.c x509write_csr.c xtea.c net_sockets.c sha512.c aria.c platform_util.c ssl_cookie.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/mbedtls/targets/: hash_wrappers.c
    mbed-os/features/nanostack/coap-service/source/: coap_connection_handler.c coap_message_handler.c coap_security_handler.c coap_service_api.c
    mbed-os/features/nanostack/mbed-mesh-api/source/: ethernet_tasklet.c mesh_system.c nd_tasklet.c thread_tasklet.c CallbackHandler.cpp LoWPANNDInterface.cpp MeshInterfaceNanostack.cpp NanostackEMACInterface.cpp NanostackEthernetInterface.cpp NanostackMemoryManager.cpp ThreadInterface.cpp
    mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/cs_nvm/: cs_nvm.c
    mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/Generic/: network_lib.c protocol_6lowpan.c protocol_6lowpan_bootstrap.c protocol_6lowpan_interface.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Core/: address.c buffer_dyn.c ns_socket.c sockbuf.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/ethernet/: ethernet_mac_api.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/serial/: serial_mac_api.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/: protocol_core.c protocol_core_sleep.c protocol_stats.c protocol_timer.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/: ccm_security.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/mbedOS/: aes_mbedtls_adapter.c
    mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/SHA256_Lib/: ns_sha256.c shalib.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/features/frameworks/greentea-client/source/: greentea_test_env.cpp greentea_serial.cpp greentea_metrics.cpp
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_types.cpp utest_stack_trace.cpp
    mbed-os/features/FEATURE_BLE/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp Gap.cpp
    mbed-os/features/FEATURE_BLE/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
    mbed-os/features/FEATURE_BLE/source/generic/: GenericGattClient.cpp GenericGap.cpp GenericSecurityManager.cpp FileSecurityDb.cpp
